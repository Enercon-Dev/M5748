<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\M5748-BL.ewp</path>
  </project>
  <batchBuild />
</workspace>
